FILES:${PN} += "/usr/lib/libtss2-tcti-device.so.*"
