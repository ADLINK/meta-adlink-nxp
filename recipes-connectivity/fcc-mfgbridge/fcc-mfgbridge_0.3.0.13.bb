PV = "0.3.0.13"
SRC_URI = "file://Bridge_${PV}-src.tgz"
require fcc-mfgbridge.inc
