PV = "0.1.0.43"
SRC_URI = "file://Bridge_${PV}-src.tgz"
require fcc-mfgbridge.inc
