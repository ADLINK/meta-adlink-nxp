
COMPATIBLE_MACHINE = "(lec-imx8mp)"
