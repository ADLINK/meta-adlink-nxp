FILESEXTRAPATHS:prepend:lec-imx8mp := "${THISDIR}/${PN}:"
