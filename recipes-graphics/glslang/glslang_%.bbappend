SRC_URI = "git://github.com/KhronosGroup/glslang.git;protocol=https;branch=main"
