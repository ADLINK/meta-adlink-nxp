PACKAGE_INSTALL:append = " packagegroup-imx-core-tools"

CORE_IMAGE_EXTRA_INSTALL:append = " \
    msgpacker \
    usb-hset \
    pwm-beeper \
    uart-mode \
    bt-hciattach \
    usb-mux \
    packagegroup-adlink \
    eltt2 \
    lvds-sscg \
    python3-msgpack \
    python3-evdev \
    mdio-tool \
    mdio-tool-scripts \
    imx-test \
    linux-serial-test \
    burn-in-test \
    ffmpeg \
    cinematicexperience-rhi \
"

