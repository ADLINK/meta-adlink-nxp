FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"



SRC_URI += "file://0002-Added-Shutdown-option.patch "

