DEMOS:append:lec-imx95 = " imx-nnstreamer-examples \
"
