ROOTFS_POSTPROCESS_COMMAND:append:lec-imx95 = "install_demo; "

