FILESEXTRAPATHS:prepend:sota := "${THISDIR}/${PN}:"
SRC_URI:append:sota = " file://ostree.scr"

