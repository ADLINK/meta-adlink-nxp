COMPATIBLE_MACHINE = "(mx8-nxp-bsp|mx9-nxp-bsp|lec-imx95)"
