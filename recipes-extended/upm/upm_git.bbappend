
SRC_URI += "\
	file://0001-Added-a-flag-to-build-upm-examples.patch \
"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
