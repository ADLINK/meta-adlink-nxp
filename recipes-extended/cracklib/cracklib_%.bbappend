SRC_URI = "git://github.com/cracklib/cracklib;protocol=https;branch=main"
