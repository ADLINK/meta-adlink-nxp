LIC_FILES_CHKSUM = "file://COPYING;md5=b234ee4d69f5fce4486a80fdaf4a4263"

SRC_URI = "git://github.com/yoctoproject/bmaptool.git;branch=main;protocol=https"

SRCREV = "c0673962a8ec1624b5189dc1d24f33fe4f06785a"
