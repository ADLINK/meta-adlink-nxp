FILESEXTRAPATHS_prepend := "${THISDIR}/qemu-native:"

SRC_URI += "file://0012-Fix-build-error-stime.patch"

