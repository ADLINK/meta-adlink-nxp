
PACKAGECONFIG_remove = "x11"
