DESCRIPTION = "ADLINK BSP Image with Wayland Weston"
LICENSE = "MIT"

require recipes-fsl/images/imx-image-multimedia.bb

#Add Chromium browser
#CORE_IMAGE_EXTRA_INSTALL += "chromium-ozone-wayland"
