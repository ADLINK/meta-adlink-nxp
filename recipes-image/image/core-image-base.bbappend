do_image_wic[depends] += "coreutils-native:do_populate_sysroot"

