RDEPENDS:packagegroup-qt6-imx:remove:lec-imx8mp = "nxp-demo-experience"
