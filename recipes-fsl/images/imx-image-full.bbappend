ROOTFS_POSTPROCESS_COMMAND:remove:mx8mp-nxp-bsp = "install_demo; "
