#Added lec-imx8qm machine as imx8qmmek for optee build.

PLATFORM_FLAVOR_lec-imx8qm   = "mx8qmmek"
