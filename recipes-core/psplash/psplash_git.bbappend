
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SPLASH_IMAGES = "file://adlink-psplash.h;outsuffix=default"
