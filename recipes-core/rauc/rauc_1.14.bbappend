FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-rauc-bootloader-print.patch"
