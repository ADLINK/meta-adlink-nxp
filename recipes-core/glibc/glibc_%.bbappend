FILESEXTRAPATHS:prepend := "${THISDIR}/glibc:"
SRC_URI += " \
    file://0001-CVE-2026-5450.patch \
    file://0002-CVE-2026-4046.patch \
    file://0003-CVE-2026-5435.patch \
    file://0004-CVE-2026-5928.patch \
"
